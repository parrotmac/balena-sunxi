inherit kernel-resin

# SRCREV = "47a070fb51bfafbce4dc6089be3a19d027d16b55"

# Disable commit SHA in kernel version string
# SCMVERSION="n"
